## drivers/misc/sensorhub/Kconfig
```kconfig
config SENSORHUB_LDISC
	tristate "Sensorhub line discipline"
	depends on TTY
	help
	  Provides line dsicipline for sensorhub
```
